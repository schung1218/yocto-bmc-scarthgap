#OBMC_IMAGE_EXTRA_INSTALL:append = " mboxd"

IMAGE_FSTYPES:append = " sdcard"
