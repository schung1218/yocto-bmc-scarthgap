FILES:openssl-conf += " ${libdir}/engines-1.1/*"
